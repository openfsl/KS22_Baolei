# Keil uVision project KS22Proj.uvprojx, settings and files
target KS22Proj_Dbg (5060020::V5.06 (build 20)::ARMCC)
  device: MKS22FN256xxx12 Freescale
  pack: Keil.Kinetis_KSxx_DFP.1.0.0-RC4
  cpu: CPUTYPE("Cortex-M4.fp")
  output: KS22Proj +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=1
  c define: CPU_MKS22FN256VLL12,
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=66,1296,186
  c include: ..\App;..\BSP;..\START;..\uCosII;..\BSP\usb_mbed\inc;..\BSP\usb_mbed\Porting;..\BSP\usb_mbed\src;..\osal\include
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x10000
  scatter file: MKS22FN256xxx12_flash.scf
  link misc: --remove
  group START
    ../START/: startup_MKS22F12.s system_MKS22F12.c system_MKS22F12.h
  group App
    ../App/: main.c hw_init.c app_can.c app_usb.c
  group BSP
    ../BSP/: bsp_pit.c bsp_uart.c bsp_clock.c bsp_led.c bsp_can.c
  group USBStack
    ../BSP/usb_mbed/Porting/: usbd_KS22.c usbd_user_cdc_acm.c usb_lib.c
    ../BSP/usb_mbed/src/: usbd_cdc_acm.c usbd_core_cdc.c usbd_core.c
